# IAR project Rcb128rfa1_ATmega128rfa1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m128rfa1 ATmega128RFA1
  ICCAVR.CCDefines: PHY_ATMEGARFA1; HAL_ATMEGA128RFA1; PLATFORM_RCB128RFA1; F_CPU=8000000
  ICCAVR.newCCIncludePaths: ../../../hal/atmega128rfa1/inc; ../../../phy/atmegarfa1/inc; ../../../nwk/inc; ../../../sys/inc; ../../../hal/drivers/atmega128rfa1; ..
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: %xcl_file%
configuration Release (AVR)
  as the first configuration, except:
  group (top)
    ../: config.h commands.c commands.h WSNDemo.c
  group stack/sys/src
    ../../../sys/src/: sysEncrypt.c sysTimer.c sys.c
  group stack/sys/inc
    ../../../sys/inc/: sysTypes.h sysTimer.h sys.h sysEncrypt.h sysConfig.h
  group stack/phy/atmegarfa1/src
    ../../../phy/atmegarfa1/src/: phy.c
  group stack/phy/atmegarfa1/inc
    ../../../phy/atmegarfa1/inc/: phy.h atmegarfa1.h
  group stack/hal/drivers/atmega128rfa1
    ../../../hal/drivers/atmega128rfa1/: halBoard.h halUart.c halSleep.c halLed.h halUart.h halSleep.h
  group stack/hal/atmega128rfa1/src
    ../../../hal/atmega128rfa1/src/: halTimer.c hal.c
  group stack/hal/atmega128rfa1/inc
    ../../../hal/atmega128rfa1/inc/: hal.h halTimer.h halGpio.h
  group stack/nwk/src
    ../../../nwk/src/: nwkRx.c nwk.c nwkRoute.c nwkRouteDiscovery.c nwkSecurity.c nwkFrame.c nwkGroup.c nwkDataReq.c nwkTx.c
  group stack/nwk/inc
    ../../../nwk/inc/: nwkTx.h nwkCommand.h nwkGroup.h nwkRouteDiscovery.h nwkRoute.h nwkDataReq.h nwk.h nwkSecurity.h nwkFrame.h nwkRx.h
