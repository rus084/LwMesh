# IAR project ZigBit_X0_ATxmega256a3u_Rf233.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3u ATxmega256a3u
  ICCAVR.CCDefines: PHY_AT86RF233; HAL_ATXMEGA256A3U; PLATFORM_ZIGBIT_X0; F_CPU=8000000
  ICCAVR.newCCIncludePaths: ../../../hal/atxmega256a3u/inc; ../../../phy/at86rf233/inc; ../../../nwk/inc; ../../../sys/inc; ../../../hal/drivers/atxmega256a3u; ..
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: %xcl_file%
configuration Release (AVR)
  as the first configuration, except:
  group (top)
    ../: config.h commands.c commands.h WSNDemo.c
  group stack/sys/src
    ../../../sys/src/: sysEncrypt.c sysTimer.c sys.c
  group stack/sys/inc
    ../../../sys/inc/: sysTypes.h sysTimer.h sys.h sysEncrypt.h sysConfig.h
  group stack/phy/at86rf233/src
    ../../../phy/at86rf233/src/: phy.c
  group stack/phy/at86rf233/inc
    ../../../phy/at86rf233/inc/: phy.h at86rf233.h
  group stack/hal/atxmega256a3u/src
    ../../../hal/atxmega256a3u/src/: halPhy.c hal.c halTimer.c
  group stack/hal/atxmega256a3u/inc
    ../../../hal/atxmega256a3u/inc/: halTimer.h halPhy.h hal.h halGpio.h
  group stack/hal/drivers/atxmega256a3u
    ../../../hal/drivers/atxmega256a3u/: halSleep.c halLed.h halUart.c halSleep.h halUart.h halBoard.h
  group stack/nwk/src
    ../../../nwk/src/: nwkRx.c nwk.c nwkRoute.c nwkRouteDiscovery.c nwkSecurity.c nwkFrame.c nwkGroup.c nwkDataReq.c nwkTx.c
  group stack/nwk/inc
    ../../../nwk/inc/: nwkTx.h nwkCommand.h nwkGroup.h nwkRouteDiscovery.h nwkRoute.h nwkDataReq.h nwk.h nwkSecurity.h nwkFrame.h nwkRx.h
