<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ZigBit_X0_ATxmega256a3u_Rf233.ewp</path>
  </project>
</workspace>


